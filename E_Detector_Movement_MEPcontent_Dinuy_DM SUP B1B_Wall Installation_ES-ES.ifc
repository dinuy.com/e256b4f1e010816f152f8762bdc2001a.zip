Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2025-11-06T14:46:21+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; S4R_Use_nominal_diameter: yes; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: E_Detector_Movement_MEPcontent_Dinuy_DM SUP B1B_Wall Installation_ES-ES:DM SUP B1B, E_Detector_Movement_MEPcontent_Dinuy_DM SUP B1B_Wall Installation_ES-ES:DM SUP B1B:1672118
In: F00
Type - Material: Color RGB 080-080-080, Color RGB 9002, Color RGB 191-191-191
Type - Constraints - Default Elevation: 0 mm
Type - Data - Detection Diameter (m): 11; Environmental Protection: IP55, Class II; Frequency: 50/60 Hz; Maximum Operating Temperature: 55 C; Mounting: Wall or corner; Mounting Height (m): 2.5; Output Channels: 1
Type - Dimensions - Depth: 50 mm; Height: 80 mm; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Width: 80 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Hertz: 50 Hz; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Detector de movimiento y presencia montado en pared 180º blanco; Article Type: DM SUP B1B; Base Family Version: 25.12; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Detector de movimiento y presencia montado en pared 180º blanco; EMCS Version: 5.0; ETIM Article Class: EC000133; Family Version: 25.12; GLN: 8422447000009; GTIN: 8422447018356; Manufacturer: Dinuy; Manufacturer Art. No.: DM SUP B1B; Manufacturer URL: https://dinuy.com/es/producto/811/detector-de-movimiento-y-presencia-de-superficie-en-pared-180-blanco; MEPcontent Class: DETECTOR_MOVEMENT; Model: DM SUP B1B; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Line: Dinuy; Revit Version: 2023; Type Name: DM SUP B1B; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Body Color: Color RGB 9002
Type - Mechanical - Weight: 0.15 kg
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Security Devices; Family Name: E_Detector_Movement_MEPcontent_Dinuy_DM SUP B1B_Wall Installation_ES-ES
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dinuy
Pset_BuildingElementProxyCommon - Reference: DM SUP B1B
Pset_EnvironmentalImpactIndicators - Reference: DM SUP B1B
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 56.7512 m2; FOD Diameter (mm): 11000 mm; FOD Height (mm): 2500 mm; Rotation U-Axis: 0 deg; Rotation U-Axis Correction: 90 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000191324 m3
Identity Data - Function Code: E6311; Mark: 1
Other - Family: E_Detector_Movement_MEPcontent_Dinuy_DM SUP B1B_Wall Installation_ES-ES; Family and Type: E_Detector_Movement_MEPcontent_Dinuy_DM SUP B1B_Wall Installation_ES-ES: DM SUP B1B; Type: DM SUP B1B; Type Id: 1672103
Phasing - Phase Created: 4. Plan over 10 years
Visibility - FOD Visibility: no

# IfcDistributionPort, Port_1672118
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: SECURITY
